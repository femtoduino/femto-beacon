# IAR project clock_quick_start_clock_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; __SAMD20J18__; BOARD=SAMD20_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../clock_samd20; ../../../../power; ../../../../reset; ../../../../../../utils/preprocessor; ../../../../../../boards/samd20_xplained_pro; ../../../../../../utils/cmsis/samd20/source; ../..; ../../../../../../utils; ../../../../../port; ../../../../../../boards; ../../../../../../../common/utils; ../../../../interrupt/system_interrupt_samd20; ../../../../interrupt; ../../../../power/power_sam_d_r; ../../../../reset/reset_sam_d_r; ../../../../../../../common/boards; ../../../../../../utils/cmsis/samd20/include; ../../../../pinmux; ..; ../../../..; ../../../../../../utils/header_files; ../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM0=true; __SAMD20J18__; BOARD=SAMD20_XPLAINED_PRO
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: clock_quick_start_clock_flash.bin
  ILINK.IlinkOutputFile: clock_quick_start_clock_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../clock_samd20/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../: qs_clock_source.c
  group sam0/drivers/system/clock/quick_start_clock/samd20_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/drivers/system/clock/quick_start_clock/samd20_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system/interrupt
    ../../../../interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../power/power_sam_d_r/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../reset/reset_sam_d_r/: reset.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../../utils/cmsis/samd20/include/: samd20g17.h samd20e16.h samd20g15.h samd20e18.h samd20e17.h samd20g18u.h samd20j15.h samd20j17.h samd20j18.h samd20e15.h samd20g18.h samd20g17u.h samd20g14.h samd20e14.h samd20g16.h samd20j14.h samd20j16.h samd20.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../utils/cmsis/samd20/include/instance/: dac.h pac2.h gclk.h sercom4.h sercom1.h adc.h tc4.h tc0.h sercom5.h dsu.h tc2.h pm.h eic.h wdt.h tc6.h nvmctrl.h tc5.h tc3.h sercom2.h port.h sysctrl.h rtc.h tc7.h tc1.h pac1.h evsys.h sercom3.h sercom0.h pac0.h ac.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../utils/cmsis/samd20/include/component/: sysctrl.h evsys.h dac.h ac.h gclk.h eic.h tc.h nvmctrl.h port.h dsu.h rtc.h wdt.h adc.h sercom.h pm.h pac.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../utils/cmsis/samd20/include/pio/: samd20j14.h samd20g16.h samd20j18.h samd20j17.h samd20g17.h samd20j15.h samd20g17u.h samd20g18u.h samd20e18.h samd20g15.h samd20e15.h samd20e1f.h samd20e17.h samd20g14.h samd20e14.h samd20j16.h samd20g18.h samd20e16.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: mrecursion.h stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../../boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
