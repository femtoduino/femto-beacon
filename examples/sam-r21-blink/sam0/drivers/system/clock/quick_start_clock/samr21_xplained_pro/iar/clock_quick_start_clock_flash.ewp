# IAR project clock_quick_start_clock_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMR21_XPLAINED_PRO; __SAMR21G18A__
  ICCARM.CCIncludePath2: ../../../clock_samd21_r21; ../../../../../port; ../../../../reset; ../../../../interrupt/system_interrupt_samr21; ../../../../../../utils/preprocessor; ../../../../../../utils/cmsis/samr21/source; ../..; ../../../../../../utils; ../../../../power; ../../../../../../boards; ../../../../../../../common/utils; ../../../../interrupt; ../../../../power/power_sam_d_r; ../../../../reset/reset_sam_d_r; ../../../../../../boards/samr21_xplained_pro; ../../../../../../utils/cmsis/samr21/include; ../../../../../../../common/boards; ../../../../pinmux; ../../../..; ..; ../../../../../../utils/header_files; ../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM0=true; BOARD=SAMR21_XPLAINED_PRO; __SAMR21G18A__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: clock_quick_start_clock_flash.bin
  ILINK.IlinkOutputFile: clock_quick_start_clock_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../../utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../../utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../../utils/cmsis/samr21/include/: samr21e18a.h samr21.h samr21g17a.h samr21g16a.h samr21e16a.h samr21e17a.h samr21g18a.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../../utils/cmsis/samr21/include/component/: mtb.h sysctrl.h hmatrixb.h wdt.h ac.h sercom.h dmac.h gclk.h pm.h pac.h adc.h nvmctrl.h eic.h port.h rfctrl.h rtc.h dsu.h evsys.h tcc.h tc.h usb.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../../utils/cmsis/samr21/include/instance/: tcc1.h pac2.h sercom5.h sercom3.h tc3.h adc.h mtb.h dsu.h pm.h rtc.h sercom1.h sercom4.h tc5.h eic.h evsys.h nvmctrl.h usb.h tc4.h sysctrl.h sercom2.h gclk.h dmac.h sercom0.h pac0.h tcc2.h tcc0.h rfctrl.h port.h wdt.h sbmatrix.h pac1.h ac.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../../utils/cmsis/samr21/include/pio/: samr21g18a.h samr21g16a.h samr21e17a.h samr21g17a.h samr21e16a.h samr21e18a.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: mrecursion.h stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/drivers/system
    ../../../../: system.c system.h
  group sam0/drivers/system/clock
    ../../../: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../clock_samd21_r21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../: qs_clock_source.c
  group sam0/drivers/system/clock/quick_start_clock/samr21_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/drivers/system/clock/quick_start_clock/samr21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system/pinmux
    ../../../../pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../power/power_sam_d_r/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../reset/reset_sam_d_r/: reset.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../../boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
