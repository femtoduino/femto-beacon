# IAR project clock_quick_start_clock_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; __SAML21J18A__; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../power; ../../../../reset; ..; ../../../../../../boards/saml21_xplained_pro; ../../../../../../utils/preprocessor; ../..; ../../../../../../utils; ../../../../../port; ../../../../../../boards; ../../../../../../../common/utils; ../../../../interrupt; ../../../../power/power_sam_l; ../../../../../../utils/header_files; ../../../../interrupt/system_interrupt_saml21; ../../../../../../utils/cmsis/saml21/include; ../../../clock_saml21; ../../../../../../../common/boards; ../../../../reset/reset_sam_l; ../../../../pinmux; ../../../..; ../../../../../../utils/cmsis/saml21/source; ../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM0=true; __SAML21J18A__; BOARD=SAML21_XPLAINED_PRO
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: clock_quick_start_clock_flash.bin
  ILINK.IlinkOutputFile: clock_quick_start_clock_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/boards/saml21_xplained_pro
    ../../../../../../boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group sam0/drivers/system
    ../../../../: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../: gclk.h clock.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../: qs_clock_source.c
  group sam0/drivers/system/clock/quick_start_clock/saml21_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/drivers/system/clock/quick_start_clock/saml21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../clock_saml21/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../reset/reset_sam_l/: reset.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../../utils/cmsis/saml21/include/: saml21e16a.h saml21g16a.h saml21e15a.h saml21e17a.h saml21.h saml21j17a.h saml21j18a.h saml21g17a.h saml21g18a.h saml21j16a.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../../utils/cmsis/saml21/include/instance/: tcc0.h tcc2.h tc3.h tal.h wdt.h evsys.h tc0.h sercom4.h nvmctrl.h sercom0.h sercom2.h dmac.h tcc1.h osc32kctrl.h tc2.h tc4.h mtb.h ac.h adc.h sercom5.h port.h supc.h pm.h rtc.h usb.h oscctrl.h mclk.h aes.h ccl.h gclk.h dac.h pac.h dsu.h tc1.h rstc.h opamp.h trng.h eic.h sercom1.h sercom3.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../../utils/cmsis/saml21/include/component/: ac.h dac.h evsys.h adc.h pac.h wdt.h nvmctrl.h dsu.h dmac.h sercom.h osc32kctrl.h rstc.h eic.h supc.h rtc.h mtb.h trng.h gclk.h opamp.h aes.h pm.h tc.h tal.h ccl.h mclk.h port.h tcc.h oscctrl.h usb.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../../utils/cmsis/saml21/include/pio/: saml21e17a.h saml21j18a.h saml21e16a.h saml21g18a.h saml21g17a.h saml21e15a.h saml21j17a.h saml21g16a.h saml21j16a.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
