# IAR project device_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAM3S_EK2; _ASSERT_ENABLE_; __SAM3SD8C__; UDD_ENABLE; ARM_MATH_CM3=true; TEST_SUITE_DEFINE_ASSERT_MACRO
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../serial; ../../../../../../../../../sam/utils/cmsis/sam3s8/source/templates; ../../../../../../../../../sam/boards; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../..; ../../../../../../../clock; ../../../../../../../../../sam/drivers/matrix; ../..; ../../../../../../../../utils/stdio/stdio_serial; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/udp; ..; ../../../../../../../../../sam/boards/sam3s_ek2; ../../../../../../../gpio; ../../../../../../../../../sam/drivers/uart; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/usart; ../../../../../../../serial/sam_uart; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../../sam/utils/cmsis/sam3s8/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_unit_tests_flash.bin
  ILINK.IlinkOutputFile: device_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam3s8/source/templates/: system_sam3sd8.c exceptions.c system_sam3sd8.h exceptions.h
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/cmsis/sam3s8/include
    ../../../../../../../../../sam/utils/cmsis/sam3s8/include/: sam3sd8c.h sam3sd8b.h sam3s8c.h sam3s8b.h sam3s8.h
  group sam/utils/cmsis/sam3s8/include/component
    ../../../../../../../../../sam/utils/cmsis/sam3s8/include/component/: component_efc.h component_acc.h component_supc.h component_tc.h component_spi.h component_matrix.h component_rstc.h component_pdc.h component_dacc.h component_udp.h component_hsmci.h component_adc.h component_usart.h component_gpbr.h component_crccu.h component_pio.h component_rtc.h component_wdt.h component_chipid.h component_pmc.h component_pwm.h component_twi.h component_rtt.h component_uart.h component_smc.h component_ssc.h
  group sam/utils/cmsis/sam3s8/include/instance
    ../../../../../../../../../sam/utils/cmsis/sam3s8/include/instance/: instance_adc.h instance_uart1.h instance_usart1.h instance_pioc.h instance_tc0.h instance_twi0.h instance_tc1.h instance_udp.h instance_ssc.h instance_rtt.h instance_twi1.h instance_rstc.h instance_supc.h instance_pioa.h instance_crccu.h instance_usart0.h instance_chipid.h instance_pwm.h instance_usart2.h instance_efc.h instance_gpbr.h instance_acc.h instance_hsmci.h instance_pmc.h instance_smc.h instance_wdt.h instance_uart0.h instance_matrix.h instance_piob.h instance_rtc.h instance_dacc.h instance_spi.h
  group sam/utils/cmsis/sam3s8/include/pio
    ../../../../../../../../../sam/utils/cmsis/sam3s8/include/pio/: pio_sam3s8b.h pio_sam3sd8c.h pio_sam3s8c.h pio_sam3sd8b.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/uart
    ../../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/udp
    ../../../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/matrix
    ../../../../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/boards/sam3s_ek2
    ../../../../../../../../../sam/boards/sam3s_ek2/: led.c init.c sam3s_ek2.h led.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../serial/sam_uart/: uart_serial.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/class/cdc/device/unit_tests
    ../../: unit_tests.c unit_tests.h conf_usb.h
  group common/services/usb/class/cdc/device/unit_tests/sam3sd8c_sam3s_ek2
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sleepmgr.h conf_test.h
  group common/services/usb/class/cdc/device/unit_tests/sam3sd8c_sam3s_ek2/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udc_desc.h udd.h udc.h
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/sam3s
    ../../../../../../../clock/sam3s/: sysclk.c genclk.h osc.h sysclk.h pll.h
  group common/services/gpio
    ../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../boards/: board.h
