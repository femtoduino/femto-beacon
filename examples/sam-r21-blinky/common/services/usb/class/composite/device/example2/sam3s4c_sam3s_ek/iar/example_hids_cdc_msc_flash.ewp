# IAR project example_hids_cdc_msc_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; ACCESS_USB_ENABLED; UDD_ENABLE; ARM_MATH_CM3=true; VIRTUAL_MEMORY_ENABLE; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ../../../../../cdc/device; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pmc; ../../../../../msc; ../..; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../../../sam/utils/cmsis/sam3s/include; ../../../../../../../ioport; ../../../../../hid/device/kbd; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../../../../../sam/utils/cmsis/sam3s/source/templates; ../../../../../cdc; ../../../../../hid/device/mouse; ../../../../../msc/device; ../../../../../../../../../sam/boards/sam3s_ek; ../../../../../../../clock; ../../../../../../../../../sam/drivers/matrix; ../../../../../../../../../sam/boards; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/udp; ../../../../../../../gpio; ../../../../../../../../../sam/utils; ../../../../../hid/device; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ..; ../../../../../../../../../sam/drivers/pio; ../../../../../hid; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example_hids_cdc_msc_flash.bin
  ILINK.IlinkOutputFile: example_hids_cdc_msc_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/udp
    ../../../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/matrix
    ../../../../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/boards/sam3s_ek
    ../../../../../../../../../sam/boards/sam3s_ek/: init.c led.c sam3s_ek.h led.h
  group sam/utils
    ../../../../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam3s/source/templates/: exceptions.c system_sam3s.c system_sam3s.h exceptions.h
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/utils/cmsis/sam3s/include
    ../../../../../../../../../sam/utils/cmsis/sam3s/include/: sam3s.h sam3s4a.h sam3s2c.h sam3s4c.h sam3s2a.h sam3s1b.h sam3s1a.h sam3s2b.h sam3s4b.h sam3s1c.h
  group sam/utils/cmsis/sam3s/include/instance
    ../../../../../../../../../sam/utils/cmsis/sam3s/include/instance/: instance_udp.h instance_rstc.h instance_crccu.h instance_chipid.h instance_wdt.h instance_matrix.h instance_uart1.h instance_dacc.h instance_supc.h instance_efc.h instance_gpbr.h instance_acc.h instance_smc.h instance_adc.h instance_ssc.h instance_usart1.h instance_rtc.h instance_twi0.h instance_piob.h instance_pmc.h instance_pwm.h instance_rtt.h instance_tc1.h instance_pioa.h instance_usart0.h instance_hsmci.h instance_pioc.h instance_uart0.h instance_twi1.h instance_spi.h instance_tc0.h
  group sam/utils/cmsis/sam3s/include/pio
    ../../../../../../../../../sam/utils/cmsis/sam3s/include/pio/: pio_sam3s2c.h pio_sam3s1b.h pio_sam3s2a.h pio_sam3s2b.h pio_sam3s4c.h pio_sam3s1a.h pio_sam3s4a.h pio_sam3s1c.h pio_sam3s4b.h
  group sam/utils/cmsis/sam3s/include/component
    ../../../../../../../../../sam/utils/cmsis/sam3s/include/component/: component_rtc.h component_twi.h component_ssc.h component_efc.h component_rtt.h component_chipid.h component_pdc.h component_rstc.h component_supc.h component_spi.h component_adc.h component_udp.h component_pio.h component_tc.h component_wdt.h component_pmc.h component_crccu.h component_dacc.h component_acc.h component_usart.h component_hsmci.h component_matrix.h component_pwm.h component_uart.h component_smc.h component_gpbr.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/hid
    ../../../../../hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../../hid/device/: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../../../hid/device/mouse/: udi_hid_mouse.c udi_hid_mouse.h
  group common/services/usb/class/hid/device/kbd
    ../../../../../hid/device/kbd/: udi_hid_kbd.c udi_hid_kbd.h
  group common/services/usb/class/cdc
    ../../../../../cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../cdc/device/: udi_cdc.c udi_cdc.h
  group common/services/usb/class/composite/device
    ../../../: udi_composite_desc.c udi_composite_conf.h
  group common/services/usb/class/composite/device/example2
    ../../: uart_sam.c memories_initialization_sam.c main.c uart.h conf_usb.h main.h ui.h
  group common/services/usb/class/composite/device/example2/sam3s4c_sam3s_ek
    ../: ui.c conf_virtual_mem.h conf_clock.h conf_board.h conf_sleepmgr.h conf_example.h conf_access.h
  group common/services/usb/class/composite/device/example2/sam3s4c_sam3s_ek/iar
    ./: asf.h
  group common/services/usb/class/msc
    ../../../../../msc/: sbc_protocol.h usb_protocol_msc.h spc_protocol.h
  group common/services/usb/class/msc/device
    ../../../../../msc/device/: udi_msc.c udi_msc.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udc_desc.h udd.h udc.h
  group common/services/clock
    ../../../../../../../clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/sam3s
    ../../../../../../../clock/sam3s/: sysclk.c genclk.h osc.h sysclk.h pll.h
  group common/services/gpio
    ../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../../../../boards/: board.h
