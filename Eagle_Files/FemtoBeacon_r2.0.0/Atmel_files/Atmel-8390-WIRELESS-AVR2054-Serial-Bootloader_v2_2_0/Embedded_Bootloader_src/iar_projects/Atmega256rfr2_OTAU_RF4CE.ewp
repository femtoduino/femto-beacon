# IAR project Atmega256rfr2_OTAU_RF4CE.ewp, settings and files
configuration Bootloader_Atmega256rfr2 (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: ATMEGA256RFR2; EXT_MEMORY; INCLUDE_RF4CE_FUNCTIONS; DISABLE_FLASH_SWAP_RF4CE_FUNCTION
  ICCAVR.CCDiagSuppress: Pa050, Pe188
  ICCAVR.newCCIncludePaths: ../application/common/include; ..; ../application/avr/include
  ICCAVR.PreInclude: configuration.h
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XExtraOptions: -f ../linkerScr/atmega256rfr2otau.xcl
  group common/include
    ../application/common/include/: abstractSerializer.h bootStructure.h srecParser.h types.h
  group common/src
    ../application/common/src/: abstractSerializer.c bootloader.c extMemReader.c memAt25df041a.c memAt25f2048.c memAt45db041.c srecParser.c
  group configuration
    ../: configuration.h
  group include
    ../application/avr/include/: eepromLoader.h hardwareInit.h rf4ceFlash.h sp_driver.h spiMemInterface.h timerInterval.h twiSerializer.h uartSerializer.h usbFifoSerializer.h
  group src
    ../application/avr/src/: calibMeasurement.s90 eepromLoader.c flashLoader.c hardwareInit.c rf4ceFlash.c sp_driver.s90 spiMemInterface.c twiSerializer.c uartSerializer.c usbFifoSerializer.c
