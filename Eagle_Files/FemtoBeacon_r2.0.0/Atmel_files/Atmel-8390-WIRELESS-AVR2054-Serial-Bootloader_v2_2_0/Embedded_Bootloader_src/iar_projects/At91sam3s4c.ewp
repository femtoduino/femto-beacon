# IAR project At91sam3s4c.ewp, settings and files
configuration Bootloader_At91sam3s4c (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: AT91SAM3S4C
  ICCARM.CCDiagSuppress: Pa050,Pe188
  ICCARM.PreInclude: configuration.h
  ICCARM.CCIncludePath2: ../application/common/include; ..; ../application/cortexm3/include; ../../../../Components/MAC_PHY/include; ../../../../Components/MAC_PHY/MAC_ENV/include; ../../../../Components/MAC_PHY/MAC_HWI/include; ../../../../Components/MAC_PHY/MAC_HWD_PHY/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: AT91SAM3S4C
  OBJCOPY.OOCOutputFile: Bootloader.srec
  ILINK.IlinkOutputFile: Bootloader.out
  ILINK.IlinkIcfFile: ../linkerScr/at91SAM3S4C_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common/include
    ../application/common/include/: abstractSerializer.h bootStructure.h srecParser.h types.h
  group common/src
    ../application/common/src/: abstractSerializer.c bootloader.c srecParser.c
  group configuration
    ../: configuration.h
  group include
    ../application/cortexm3/include/: AT91SAM3S4.h core_cm3.h descriptors.h dfuClass.h eepromLoader.h flashLoader.h freqSelector.h hardwareInit.h preparser.h timerInterval.h usbSerializer.h usbShared.h
  group src
    ../application/cortexm3/src/: descriptors.c dfuClass.c eepromLoader.c enumeration.c flashLoader.c hardwareInit.c preparser.c startup.c usbSerializer.c vectorTable.c
