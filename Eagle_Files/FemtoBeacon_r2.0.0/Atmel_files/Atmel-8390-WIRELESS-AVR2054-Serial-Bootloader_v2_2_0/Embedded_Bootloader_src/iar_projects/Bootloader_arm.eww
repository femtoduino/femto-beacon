<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild/>
  <project>
    <path>$WS_DIR$\At91sam3s4c.ewp</path>
  </project>
</workspace>
