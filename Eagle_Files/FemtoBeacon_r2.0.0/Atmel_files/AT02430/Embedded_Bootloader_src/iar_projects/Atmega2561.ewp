# IAR project Atmega2561.ewp, settings and files
configuration Bootloader_Atmega2561 (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m2561 ATmega2561
  ICCAVR.CCDefines: ATMEGA2561
  ICCAVR.CCDiagSuppress: Pa050, Pe188
  ICCAVR.newCCIncludePaths: ../application/common/include; ..; ../application/avr/include; ../../../../Components/MAC_PHY/include; ../../../../Components/MAC_PHY/MAC_ENV/include; ../../../../Components/MAC_PHY/MAC_HWI/include; ../../../../Components/MAC_PHY/MAC_HWD_PHY/include
  ICCAVR.PreInclude: configuration.h
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  XLINK.XExtraOptions: -f ../linkerScr/atmega2561.xcl
  group common/include
    ../application/common/include/: abstractSerializer.h bootStructure.h srecParser.h twiParser.h types.h
  group common/src
    ../application/common/src/: abstractSerializer.c bootloader.c srecParser.c twiParser.c
  group configuration
    ../: configuration.h
  group include
    ../application/avr/include/: eepromLoader.h hardwareInit.h sp_driver.h timerInterval.h twiSerializer.h uartSerializer.h usbFifoSerializer.h
  group src
    ../application/avr/src/: calibMeasurement.s90 eepromLoader.c flashLoader.c hardwareInit.c sp_driver.s90 twiSerializer.c uartSerializer.c usbFifoSerializer.c
