# IAR project Atxmega128A1.ewp, settings and files
configuration Bootloader_Atxmega128A1 (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128a1 ATxmega128A1
  ICCAVR.CCDefines: ATXMEGA128A1
  ICCAVR.CCDiagSuppress: Pa050, Pe188
  ICCAVR.newCCIncludePaths: ../application/common/include; ..; ../application/xmega/include; ../../../../Components/MAC_PHY/include; ../../../../Components/MAC_PHY/MAC_ENV/include; ../../../../Components/MAC_PHY/MAC_HWI/include; ../../../../Components/MAC_PHY/MAC_HWD_PHY/include
  ICCAVR.PreInclude: configuration.h
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XExtraOptions: -f ../linkerScr/avrxmega128a1.xcl
  group common/include
    ../application/common/include/: abstractSerializer.h bootStructure.h srecParser.h twiParser.h types.h
  group common/src
    ../application/common/src/: abstractSerializer.c bootloader.c srecParser.c twiParser.c
  group configuration
    ../: configuration.h
  group include
    ../application/xmega/include/: eepromLoader.h hardwareInit.h sp_driver.h spiSerializer.h timerInterval.h twiSerializer.h uartSerializer.h
  group src
    ../application/xmega/src/: eepromLoader.c flashLoader.c hardwareInit.c sp_driver.s90 spiSerializer.c twiSerializer.c uartSerializer.c
